<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\nucleo-f411-esp8266.ewp</path>
  </project>
  <batchBuild/>
</workspace>


