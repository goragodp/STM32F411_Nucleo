<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F411_TEMP_HUMID.ewp</path>
  </project>
  <batchBuild/>
</workspace>


